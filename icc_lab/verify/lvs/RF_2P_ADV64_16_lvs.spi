$ Spice netlist generated by v2lvs
$ v2013.4_26.18    Fri Dec 13 16:21:22 PST 2013

.SUBCKT RF_2P_ADV64_16 QA[15] QA[14] QA[13] QA[12] QA[11] QA[10] QA[9] QA[8] VDD VSS
+ QA[7] QA[6] QA[5] QA[4] QA[3] QA[2] QA[1] QA[0] CLKA CENA AA[5] AA[4] AA[3]
+ AA[2] AA[1] AA[0] CLKB CENB AB[5] AB[4] AB[3] AB[2] AB[1] AB[0] DB[15] DB[14]
+ DB[13] DB[12] DB[11] DB[10] DB[9] DB[8] DB[7] DB[6] DB[5] DB[4] DB[3] DB[2]
+ DB[1] DB[0] EMAA[2] EMAA[1] EMAA[0] EMAB[2] EMAB[1] EMAB[0]
.ENDS
