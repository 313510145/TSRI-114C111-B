$ Spice netlist generated by v2lvs
$ v2014.1_36.21    Wed Apr 2 15:50:24 PDT 2014

.SUBCKT PADIN PAD C
.ENDS

.SUBCKT PADBI PAD OEN C I
.ENDS

.SUBCKT PADIOVDD VDDIO
.ENDS

.SUBCKT PADIOVSS VSSIO
.ENDS

.SUBCKT PADVDD VDD
.ENDS

.SUBCKT PADVSS VSS
.ENDS

.SUBCKT PADIOVDDPOC VDDIO
.ENDS
