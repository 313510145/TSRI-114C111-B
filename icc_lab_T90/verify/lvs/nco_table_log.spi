$ Spice netlist generated by v2lvs
$ v2010.4_26.16    Wed Dec 8 17:18:26 PST 2010

.SUBCKT nco_table_log Q[15] Q[14] Q[13] Q[12] Q[11] Q[10] Q[9] Q[8] Q[7] Q[6]
+ Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] CLK CEN A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2]
+ A[1] A[0]
.ENDS
